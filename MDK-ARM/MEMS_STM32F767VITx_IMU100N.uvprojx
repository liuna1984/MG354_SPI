# Keil uVision project MEMS_STM32F767VITx_IMU100N.uvprojx, settings and files
target MEMS_STM32F767VITx_IMU100N (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767VITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: MEMS_STM32F767VITx_IMU100N
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;       ../Drivers/CMSIS/Include;       ..\Code;       ..\Code\Device;       ..\Code\Message
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Code
    ../Code/: MainEntry.c Global.c
  group Device
    ../Code/Device/: Device.c dvc_Led.c EnhancedSTM32.c MG354_SPI.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
  group Application/User
    ../Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Message
    ../Code/Message/: Message.c msg_Qsens.c ParseFrame.c
software components: CMSIS:CORE 4.3.0
